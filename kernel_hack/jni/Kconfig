## kernel_hack/jni/Kconfig
```kconfig
config IO_MOD
    tristate "Kernel Driver to read/write memory"
    default y
    help
    This is the kernel driver for android system.
```
